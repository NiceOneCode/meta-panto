DESCRIPTION = "DMG Diner image base for geam6ul"

include dmg-panto-images-config.inc

export IMAGE_BASENAME = "dmg-filesystem-primary"
export IMAGE_NAME     =  "${MACHINE}-filesystem-primary"

