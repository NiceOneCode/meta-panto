FILESEXTRAPATHS_prepend_mx6 := "${THISDIR}/${PN}/mx6:"

SRC_URI_append = " file://defconfig "

PR = "r1"

